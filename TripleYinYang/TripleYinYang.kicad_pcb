# Repository casartar/Ad-Hoc-KiCAD-Workshop

## KiCad design TripleYinYang/TripleYinYang.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_1060_1x2032
D1, D2, D3: LED; LED_D5.0mm
R1, R2, R3: 200; R_1210_3225Metric_Pad1.30x2.65mm_HandSolder
SW1: SW_DPDT_x2; MSS22D18G2

Connections:
+3V0: BT1.1 (+), R1.1, R2.1, R3.1
GND: D1.1 (K), D2.1 (K), D3.1 (K), SW1.1 (A)
unnamed: BT1.2 (-), SW1.2 (B)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2

Board: 2 copper layers, 100.0 x 100.0 mm, 8 parts (8 on the bottom side), 6 nets.
